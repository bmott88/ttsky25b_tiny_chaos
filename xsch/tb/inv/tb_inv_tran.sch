** sch_path: xsch/tb/inv/tb_inv_tran.sch
**.subckt tb_inv_tran
Vin in GND pulse(0 1.8 95n 2n 2n 90n 180n)
VDD VDD GND 1.8
* noconn out
X1 out in inv
XM1 out2 in VDD VDD sky130_fd_pr__pfet_01v8 L=0.15 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29' as='int((1 + 2)/2) * 1 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)' nrd='0.29 / 1 ' nrs='0.29 / 1 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XM2 out2 in GND GND sky130_fd_pr__nfet_01v8 L=0.15 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29' as='int((1 + 2)/2) * 1 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)' nrd='0.29 / 1 ' nrs='0.29 / 1 '
+ sa=0 sb=0 sd=0 mult=1 m=1
* noconn out2
XM3 out3 in VDD VDD sky130_fd_pr__pfet_01v8 L=0.3 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29' as='int((1 + 2)/2) * 1 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)' nrd='0.29 / 1 ' nrs='0.29 / 1 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XM4 out3 in GND GND sky130_fd_pr__nfet_01v8 L=0.15 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29' as='int((1 + 2)/2) * 1 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)' nrd='0.29 / 1 ' nrs='0.29 / 1 '
+ sa=0 sb=0 sd=0 mult=1 m=1
* noconn out3
**** begin user architecture code



* control language script

.control
tran 100p 500n               ; simulation command 1

set xbrushwidth=2
plot v(in) v(out)
plot v(in) v(out2)
plot v(in) v(out3)
plot v(out) v(out2) v(out3)

write $inputdir/outtran.out v(in) v(out)

reset

dc vin 0 2 0.01              ; simulation command 2

plot v(out) v(out2) v(out3)               ; v(in) not required because it is the x axis already

write $inputdir/outdc.out v(out)

.endc
.end



.lib $::SKYWATER_MODELS/sky130.lib.spice tt
**** end user architecture code
**.ends

* expanding   symbol:  /home/bmott/ttsky25b_tiny_chaos/xsch/ip/logic/inv/inv.sym # of pins=2
** sym_path: /home/bmott/ttsky25b_tiny_chaos/xsch/ip/logic/inv/inv.sym
** sch_path: /home/bmott/ttsky25b_tiny_chaos/xsch/ip/logic/inv/inv.sch
.subckt inv OUT[expr(@width - 1):0] IN[expr(@width - 1):0]
*.ipin IN[@width - 1:0]
*.opin OUT[@width - 1:0]
M1[@width - 1:0] OUT[@width - 1:0] IN[@width - 1:0] GND GND cmosn w=2u l=1u m=1
M2[@width -1:0] OUT[@width - 1:0] IN[@width - 1:0] VDD VDD cmosp w=5u l=1u m=1
.ends

.GLOBAL VDD
.GLOBAL GND
.end
